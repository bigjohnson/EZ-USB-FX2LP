# Keil uVision project bulkloop.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2 (CY7C68XXX) Cypress
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0xE000-0xE1FF) CLOCK(48000000) MODDP2
  output: bulkloop +hex
  AfterMake: "C:\Cypress\Cypress Suite USB 3.4.7\Firmware\bin\hex2bix" -i -f 0xC2 -o %L.iic %L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Cypress\Cypress Suite USB 3.4.7\Firmware\inc\;C:\Cypress\Cypress Suite USB 3.4.7\Firmware\lib\
  group Source Group 1
    ./: fw.c bulkloop.c dscr.a51
    C:/Cypress/Cypress Suite USB 3.4.7/Firmware/lib/: EZUSB.LIB USBJmpTb.OBJ
