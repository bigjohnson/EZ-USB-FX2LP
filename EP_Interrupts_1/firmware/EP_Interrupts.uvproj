# Keil uVision project EP_Interrupts.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2LP (CY7C68XXX-X) Cypress
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0xE000-0xE1FF) CLOCK(48000000) MODDP2
  output: EP_Interrupts +hex
  AfterMake: "C:\Cypress\Cypress Suite USB 3.4.7\Firmware\bin\hex2bix" -i -f 0xC2 -o EP_Interrupts.iic EP_Interrupts.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Cypress\USB\CY3684_EZ-USB_FX2LP_DVK\1.1\Target\Inc\
  group Source Group 1
    ./: EP_Interrupts.c fw.c dscr.a51
    C:/Cypress/Cypress Suite USB 3.4.7/Firmware/lib/: USBJmpTb.OBJ EZUSB.LIB
